# IAR project FreeRtos_Stu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F30X_HD; _ANYID_GD32_GDLIB; _ANYID_STM32L4_
  ICCARM.CCIncludePath2: ..\Kernel; ..\Kernel\inc; ..\Kernel\portable\MemMang; ..\Kernel\portable\IAR\ARM_CM4F; ..\DeviceLib\inc; ..\Cmsis\GD\inc; ..\User\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: E:\AnyID\Git\FreeRtos_Stu\Kernel\portable\IAR\ARM_CM4F; E:\AnyID\Git\FreeRtos_Stu\Kernel\inc
  ILINK.IlinkOutputFile: FreeRtos_Stu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Cmsis
    ../Cmsis/GD/src/: startup_gd32f30x_hd.s system_gd32f30x.c
  group DeviceLib
    ../DeviceLib/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_it.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Kernel
    ../Kernel/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Kernel/portable/IAR/ARM_CM4F
    ../Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Kernel/portable/IAR/MemMang
    ../Kernel/portable/MemMang/: heap_4.c
  group Main
    ../Main/: mian.c
  group User
    ../User/src/: Anyid_CS1110_Reader.c Anyid_CS1110_Wight.c Anyid_CS1110_Wight_HL.c AnyID_Uart_Receive.c SysCfg.c Uart2.c Uart2_HL.c
    ../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
